# Keil uVision project BMWJJ.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BMWJJ
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_DBG_PRINT
  c misc: --no-multibyte-chars
  c include: .\BSP;.\phApp;.\NxpRdLib\types;.\NxpRdLib\intfs;.\NxpRdLib\comps\phacDiscLoop\src\Sw;.\NxpRdLib\comps\phalMfc\src;.\NxpRdLib\comps\phalMfc\src\Sw;.\NxpRdLib\comps\phhalHw\src\Rc523;.\NxpRdLib\comps\phpalI14443p3a\src\Sw;.\NxpRdLib\comps\phpalI14443p3b\src\Sw;.\NxpRdLib\comps\phpalI14443p4\src\Sw;.\NxpRdLib\comps\phpalI14443p4a\src\Sw
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application Source
    ./Application/: AddCard.c AddFP.c AlertUtil.c DeviceMng.c Display.c FileSysUtil.c IdentifyProc.c KeyProc.c main.c MessageProc.c MPUtil.c StringUtil.c Unlock.c
  group Application Head
    ./Application/: AddCard.h AddFP.h AlertUtil.h DeviceMng.h Display.h FileSysUtil.h MPUtil.h StringUtil.h Unlock.h
  group BSP Source
    ./BSP/: BQ34Z100.c Buzzer.c DbgPrint.c FP_Reader.c I2C_Soft.c IWDG.c Keypad.c LCD_TJC4024.c LED.c Motor.c RTC_PCF8563.c RFID_Reader.c Sensor.c USART_Util.c User_HID_0.c
  group BSP Head
    ./BSP/: BQ34Z100.h Buzzer.h DbgPrint.h FP_Reader.h I2C_Soft.h IWDG.h Keypad.h LCD_TJC4024.h LED.h Motor.h RTC_PCF8563.h RFID_Reader.h Sensor.h USART_Util.h User_HID_0.h
  group phApp
    ./phApp/: ISO14443-4.h RFCARD_App_Rc531.c RFCARD_App_Rc531.h RFCARD_Init.c RFCARD_Init.h
  group phacDiscLoop
    ./NxpRdLib/comps/phacDiscLoop/src/: phacDiscLoop.c
    ./NxpRdLib/comps/phacDiscLoop/src/Sw/: phacDiscLoop_Sw.c phacDiscLoop_Sw_Int.c
  group phalMfc
    ./NxpRdLib/comps/phalMfc/src/: phalMfc.c phalMfc_Int.c
    ./NxpRdLib/comps/phalMfc/src/Sw/: phalMfc_Sw.c
  group phalMful
    ./NxpRdLib/comps/phalMful/src/: phalMful.c phalMful_Int.c
    ./NxpRdLib/comps/phalMful/src/Sw/: phalMful_Sw.c
  group phbalReg
    ./NxpRdLib/comps/phbalReg/src/: phbalReg.c
    ./NxpRdLib/comps/phbalReg/src/Stub/: phbalReg_Stub.c
  group phhalHw
    ./NxpRdLib/comps/phhalHw/src/: phhalHw.c
    ./NxpRdLib/comps/phhalHw/src/Rc523/: phhalHw_Rc523.c phhalHw_Rc523_Cmd.c phhalHw_Rc523_Int.c phhalHw_Rc523_Wait.c
  group phpalFelica
    ./NxpRdLib/comps/phpalFelica/src/: phpalFelica.c
    ./NxpRdLib/comps/phpalFelica/src/Sw/: phpalFelica_Sw.c
  group phpalI14443p3a
    ./NxpRdLib/comps/phpalI14443p3a/src/Sw/: phpalI14443p3a_Sw.c
  group phpalI14443p3b
    ./NxpRdLib/comps/phpalI14443p3b/src/Sw/: phpalI14443p3b_Sw.c
  group phpalI14443p4
    ./NxpRdLib/comps/phpalI14443p4/src/Sw/: phpalI14443p4_Sw.c
    ./NxpRdLib/comps/phpalI14443p4/src/: phpalI14443p4.c
  group phpalI14443p4a
    ./NxpRdLib/comps/phpalI14443p4a/src/Sw/: phpalI14443p4a_Sw.c
  group phpalI18092mPI
    ./NxpRdLib/comps/phpalI18092mPI/src/: phpalI18092mPI.c
    ./NxpRdLib/comps/phpalI18092mPI/src/Sw/: phpalI18092mPI_Sw_Int.c phpalI18092mPI_Sw.c
  group phpalMifare
    ./NxpRdLib/comps/phpalMifare/src/: phpalMifare.c
    ./NxpRdLib/comps/phpalMifare/src/Sw/: phpalMifare_Sw.c
  group phKeyStore
    ./NxpRdLib/comps/phKeyStore/src/: phKeyStore.c
    ./NxpRdLib/comps/phKeyStore/src/Sw/: phKeyStore_Sw.c
  group phTools
    ./NxpRdLib/comps/phTools/src/: phTools.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:Event Recorder 1.4.0, Compiler:I/O:File 1.2.0, File System:CORE 6.11.0, File System:Drive:Memory Card 6.11.0, USB:CORE 6.13.0, USB:Device 6.13.0, USB:Device:HID 6.13.0, CMSIS Driver:SPI 2.2, CMSIS Driver:USB Device 2.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
